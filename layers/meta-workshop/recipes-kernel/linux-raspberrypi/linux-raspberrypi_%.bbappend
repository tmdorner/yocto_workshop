FILESEXTRAPATHS:prepend := "${THISDIR}/linux-raspberrypi:"

SRC_URI += "\
	file://lsm9ds0.cfg \
	"