LICENSE = "CLOSED"

inherit pypi setuptools3
SRC_URI[sha256sum] = "7c91c8440ed8390cbe34c6878deeefd90730d186b0015a89b6772aa3df5b2831"

PYPI_PACKAGE = "pipoe"
S = "${WORKDIR}/pipoe-2019.11"